File: board/mux.kicad_sch (KiCad schematic)
At the start: 2 parts, among them U1 ADG707BRUZ-REEL7

Commit message: added lcsc part numbers
Parts:
- U1: lcsc (none) -> C246080
